<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\GenericApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>GenericApp</project>
        <configuration>CoordinatorDB</configuration>
      </member>
      <member>
        <project>GenericApp</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>GenericApp</project>
        <configuration>RouterDB</configuration>
      </member>
      <member>
        <project>GenericApp</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>GenericApp</project>
        <configuration>EndDeviceDB</configuration>
      </member>
      <member>
        <project>GenericApp</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


